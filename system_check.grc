options:
  parameters:
    generate_options: qt_gui
    id: first_try_pa
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: d_x
  id: variable
  parameters:
    value: wavelength / 2
  states: {}
- name: jammer_angle
  id: variable
  parameters:
    value: np.radians(30)
  states: {}
- name: phase_shift
  id: variable
  parameters:
    value: 2 * np.pi * (d_x / wavelength) * np.sin(jammer_angle)
  states: {}
- name: pilot_offset
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: wavelength
  id: variable
  parameters:
    value: 99792458.0 / 2.4e9
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 10e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 10e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 10e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 10e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_3
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 500e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_3_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: beamod_mvdr_beamformer_0
  id: beamod_mvdr_beamformer
  parameters:
    ant_positions: '[0, d_x, 2*d_x, 3*d_x]'
    freq: 2.4e9
    snapshots: 512 * 10
    target_angle: '0.0'
  states: {}
- name: beamod_pilot_sync_0
  id: beamod_pilot_sync
  parameters: {}
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_2
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(-0 * phase_shift)
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: int(1 * phase_shift)
    type: complex
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: int(2 * phase_shift)
    type: complex
  states: {}
- name: blocks_delay_0_2
  id: blocks_delay
  parameters:
    delay: int(3 * phase_shift)
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-pilot_offset'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 10e3, 2e3)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-pilot_offset'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 10e3, 2e3)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_delay_0_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_delay_0_1, '0']
- [analog_sig_source_x_0_2, '0', blocks_delay_0_2, '0']
- [analog_sig_source_x_0_3, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_3, '0', blocks_add_xx_0_0, '0']
- [analog_sig_source_x_0_3, '0', blocks_add_xx_0_1, '0']
- [analog_sig_source_x_0_3, '0', blocks_add_xx_0_2, '0']
- [analog_sig_source_x_0_3_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_3_0, '0', blocks_multiply_xx_0_0, '1']
- [beamod_mvdr_beamformer_0, '0', qtgui_freq_sink_x_0, '1']
- [beamod_pilot_sync_0, '0', beamod_mvdr_beamformer_0, '2']
- [beamod_pilot_sync_0, '1', beamod_mvdr_beamformer_0, '3']
- [blocks_add_xx_0, '0', beamod_mvdr_beamformer_0, '0']
- [blocks_add_xx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0_0, '0', beamod_mvdr_beamformer_0, '1']
- [blocks_add_xx_0_1, '0', blocks_multiply_xx_0_0, '0']
- [blocks_add_xx_0_2, '0', blocks_multiply_xx_0, '0']
- [blocks_delay_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_delay_0_1, '0', blocks_add_xx_0_1, '1']
- [blocks_delay_0_2, '0', blocks_add_xx_0_2, '1']
- [blocks_multiply_xx_0, '0', beamod_pilot_sync_0, '1']
- [blocks_multiply_xx_0_0, '0', beamod_pilot_sync_0, '0']
- [blocks_multiply_xx_0_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_throttle2_0, '0', blocks_delay_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', beamod_pilot_sync_0, '2']
- [freq_xlating_fir_filter_xxx_0_0, '0', beamod_pilot_sync_0, '3']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
