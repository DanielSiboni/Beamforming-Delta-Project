options:
  parameters:
    generate_options: qt_gui
    id: first_try_pa
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: P_noise
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {}
- name: c_light_speed
  id: variable
  parameters:
    value: '299792458.0'
  states: {}
- name: d_x
  id: variable
  parameters:
    value: wavelength / 2
  states: {}
- name: freq_wave
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: jammer_angle
  id: variable
  parameters:
    value: np.radians(jammer_angle_deg)
  states: {}
- name: jammer_angle_deg
  id: variable_qtgui_range
  parameters:
    start: '-90'
    step: '1'
    stop: '90'
    value: '30'
  states: {}
- name: phase_shift
  id: variable
  parameters:
    value: 2 * np.pi * (d_x / wavelength) * np.sin(jammer_angle)
  states: {}
- name: pilot_offset
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: wavelength
  id: variable
  parameters:
    value: 99792458.0 / freq_wave
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: P_noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: P_noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0_1
  id: analog_noise_source_x
  parameters:
    amp: P_noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0_2
  id: analog_noise_source_x
  parameters:
    amp: P_noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_wave
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_wave
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_wave
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_wave
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_3
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: pilot_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_3_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 1.1 * freq_wave
    low_cutoff_freq: 0.9 * freq_wave
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 0.01 * freq_wave
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 1.1 * freq_wave
    low_cutoff_freq: 0.9 * freq_wave
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 0.01 * freq_wave
    win: window.WIN_HAMMING
  states: {}
- name: beamod_mvdr_beamformer_0
  id: beamod_mvdr_beamformer
  parameters:
    ant_positions: '[0, d_x, 2*d_x, 3*d_x]'
    freq: freq_wave
    snapshots: 512 * 10
    target_angle: '0.0'
  states: {}
- name: beamod_pilot_sync_0
  id: beamod_pilot_sync
  parameters: {}
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_2
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_3
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_3_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_3_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_3_2
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: np.exp(-1j * 0 * phase_shift)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: np.exp(-1j * 1 * phase_shift)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: np.exp(-1j * 2 * phase_shift)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: np.exp(-1j * 3 * phase_shift)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(10/20)
    type: complex
  states: {state: bypassed}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(10/20)
    type: complex
  states: {state: bypassed}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-pilot_offset'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 10e3, 2e3)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-pilot_offset'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 10e3, 2e3)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: freq_wave
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: freq_wave
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0_3, '1']
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0_3_0, '1']
- [analog_noise_source_x_0_1, '0', blocks_add_xx_0_3_1, '1']
- [analog_noise_source_x_0_2, '0', blocks_add_xx_0_3_2, '1']
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0_3_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_add_xx_0_3_1, '0']
- [analog_sig_source_x_0_2, '0', blocks_add_xx_0_3_2, '0']
- [analog_sig_source_x_0_3, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_3, '0', blocks_add_xx_0_0, '0']
- [analog_sig_source_x_0_3, '0', blocks_add_xx_0_1, '0']
- [analog_sig_source_x_0_3, '0', blocks_add_xx_0_2, '0']
- [analog_sig_source_x_0_3_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_3_0, '0', blocks_multiply_xx_0_0, '1']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_1, '0']
- [band_pass_filter_0_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [beamod_mvdr_beamformer_0, '0', band_pass_filter_0_0, '0']
- [beamod_mvdr_beamformer_0, '0', low_pass_filter_0, '0']
- [beamod_pilot_sync_0, '0', beamod_mvdr_beamformer_0, '2']
- [beamod_pilot_sync_0, '1', beamod_mvdr_beamformer_0, '3']
- [blocks_add_xx_0, '0', band_pass_filter_0, '0']
- [blocks_add_xx_0, '0', beamod_mvdr_beamformer_0, '0']
- [blocks_add_xx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_add_xx_0, '0', low_pass_filter_0_0, '0']
- [blocks_add_xx_0_0, '0', beamod_mvdr_beamformer_0, '1']
- [blocks_add_xx_0_1, '0', blocks_multiply_xx_0_0, '0']
- [blocks_add_xx_0_2, '0', blocks_multiply_xx_0, '0']
- [blocks_add_xx_0_3, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0_3_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_add_xx_0_3_1, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_add_xx_0_3_2, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0_1, '1']
- [blocks_multiply_const_vxx_0_0_0_0, '0', blocks_add_xx_0_2, '1']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_multiply_xx_0, '0', beamod_pilot_sync_0, '1']
- [blocks_multiply_xx_0_0, '0', beamod_pilot_sync_0, '0']
- [blocks_multiply_xx_0_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0_3, '0']
- [freq_xlating_fir_filter_xxx_0, '0', beamod_pilot_sync_0, '2']
- [freq_xlating_fir_filter_xxx_0_0, '0', beamod_pilot_sync_0, '3']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [low_pass_filter_0_0, '0', blocks_multiply_const_vxx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
