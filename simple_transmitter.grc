options:
  parameters:
    generate_options: qt_gui
    id: simple_transmitter
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq_wave
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: freq_wave_0
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: t_gain
  id: variable_qtgui_range
  parameters:
    label: Transmitter Gain
    start: '0'
    step: '1'
    stop: '50'
    value: '50'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Freq Transmit"'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq_wave
    gain0: t_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_const_source_x_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
