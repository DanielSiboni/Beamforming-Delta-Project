options:
  parameters:
    generate_options: qt_gui
    id: first_try_pa
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: c_light_speed
  id: variable
  parameters:
    value: '299792458'
  states: {}
- name: d_x
  id: variable
  parameters:
    value: lambda_wave / 2
  states: {}
- name: freq_wave
  id: variable
  parameters:
    value: 2.4e3
  states: {}
- name: lambda_wave
  id: variable
  parameters:
    value: c_light_speed/freq_wave
  states: {}
- name: noise_amp
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: phase_diff
  id: variable
  parameters:
    value: '2*np.pi* d_x * np.sin(recv_theta) / lambda_wave '
  states: {state: disabled}
- name: recv_angle
  id: variable
  parameters:
    value: '10'
  states: {}
- name: recv_theta
  id: variable_qtgui_range
  parameters:
    label: R Angle
    start: '-np.pi / 2'
    step: '0.01'
    stop: np.pi / 2
    value: '0'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: time_delay
  id: variable
  parameters:
    value: d_x*np.sin(trans_theta_radians)/c_light_speed
  states: {}
- name: trans_degs
  id: variable_qtgui_range
  parameters:
    label: T Angle
    start: '-90'
    step: '0.01'
    stop: '90'
    value: '30'
  states: {}
- name: trans_theta_radians
  id: variable
  parameters:
    value: np.radians(trans_degs)
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 2.4e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0.01'
    freq: 2.4e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SAW_WAVE
  states: {state: disabled}
- name: beamod_mvdr_beamformer_0
  id: beamod_mvdr_beamformer
  parameters:
    ant_positions: '[0, 1.2*d_x]'
    freq: freq_wave
    snapshots: '51200'
    target_angle: recv_angle
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: 1*int(time_delay*samp_rate)
    type: complex
  states: {}
- name: blocks_phase_shift_0_1
  id: blocks_phase_shift
  parameters:
    is_radians: 'True'
    shift: 1*phase_diff
  states: {state: disabled}
- name: blocks_phase_shift_0_2
  id: blocks_phase_shift
  parameters:
    is_radians: 'True'
    shift: '0.0'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Freqs"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Freqs"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Total waves"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"First Wave"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Second_wave"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_const_source_x_0_0, '0', blocks_add_xx_0_0, '0']
- [analog_const_source_x_0_0, '0', blocks_add_xx_0_0_0, '1']
- [analog_const_source_x_0_0_0, '0', blocks_add_xx_0_0, '1']
- [analog_const_source_x_0_0_0, '0', blocks_add_xx_0_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_delay_0, '0']
- [analog_sig_source_x_0, '0', blocks_delay_0_0, '0']
- [analog_sig_source_x_0_0_0, '0', blocks_add_xx_0_0, '0']
- [analog_sig_source_x_0_0_0, '0', blocks_add_xx_0_0_0, '1']
- [beamod_mvdr_beamformer_0, '0', qtgui_freq_sink_x_0_0, '0']
- [beamod_mvdr_beamformer_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_0_0, '0', beamod_mvdr_beamformer_0, '0']
- [blocks_add_xx_0_0_0, '0', beamod_mvdr_beamformer_0, '1']
- [blocks_delay_0, '0', blocks_add_xx_0_0, '1']
- [blocks_delay_0, '0', blocks_phase_shift_0_2, '0']
- [blocks_delay_0_0, '0', blocks_add_xx_0_0_0, '0']
- [blocks_delay_0_0, '0', blocks_phase_shift_0_1, '0']
- [blocks_phase_shift_0_1, '0', blocks_add_xx_0, '1']
- [blocks_phase_shift_0_2, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
