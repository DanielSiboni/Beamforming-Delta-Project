options:
  parameters:
    generate_options: qt_gui
    id: lms3
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: c_light_speed
  id: variable
  parameters:
    value: '299792458'
  states: {}
- name: d_x
  id: variable
  parameters:
    value: lambda_wave / 2
  states: {}
- name: freq_wave
  id: variable
  parameters:
    value: 2.4e3
  states: {}
- name: lambda_wave
  id: variable
  parameters:
    value: c_light_speed/freq_wave
  states: {}
- name: noise_amp
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: recv_angle
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: time_delay
  id: variable
  parameters:
    value: d_x*np.sin(trans_theta_radians)/c_light_speed
  states: {}
- name: trans_degs
  id: variable_qtgui_range
  parameters:
    label: T Angle
    start: '-90'
    step: '0.01'
    stop: '90'
    value: '10'
  states: {}
- name: trans_theta_radians
  id: variable
  parameters:
    value: np.radians(trans_degs)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.1'
    freq: 2.4e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 2.4e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: beamod_lms_beamformer_0
  id: beamod_lms_beamformer
  parameters:
    mu: '0.001'
    num_antennas: '3'
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: 1*int(time_delay*samp_rate)
    type: complex
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: 1*int(time_delay*samp_rate)
    type: complex
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: '0'
    type: complex
  states: {}
- name: blocks_delay_0_1_0
  id: blocks_delay
  parameters:
    delay: 2*int(time_delay*samp_rate)
    type: complex
  states: {}
- name: blocks_delay_0_1_1
  id: blocks_delay
  parameters:
    delay: 2*int(time_delay*samp_rate)
    type: complex
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '3'
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Freqs"'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', beamod_lms_beamformer_0, '1']
- [analog_sig_source_x_0, '0', blocks_delay_0, '0']
- [analog_sig_source_x_0, '0', blocks_delay_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_delay_0_1_1, '0']
- [analog_sig_source_x_0_0, '0', blocks_delay_0_0_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_delay_0_1, '0']
- [analog_sig_source_x_0_0, '0', blocks_delay_0_1_0, '0']
- [beamod_lms_beamformer_0, '0', qtgui_freq_sink_x_0_0, '0']
- [beamod_lms_beamformer_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_add_xx_0_0, '0', blocks_streams_to_vector_0, '0']
- [blocks_add_xx_0_0, '0', qtgui_freq_sink_x_0_0, '1']
- [blocks_add_xx_0_0_0, '0', blocks_streams_to_vector_0, '1']
- [blocks_add_xx_0_0_0_0, '0', blocks_streams_to_vector_0, '2']
- [blocks_delay_0, '0', blocks_add_xx_0_0, '1']
- [blocks_delay_0_0, '0', blocks_add_xx_0_0_0, '0']
- [blocks_delay_0_0_0, '0', blocks_add_xx_0_0_0, '1']
- [blocks_delay_0_1, '0', blocks_add_xx_0_0, '0']
- [blocks_delay_0_1_0, '0', blocks_add_xx_0_0_0_0, '1']
- [blocks_delay_0_1_1, '0', blocks_add_xx_0_0_0_0, '0']
- [blocks_streams_to_vector_0, '0', beamod_lms_beamformer_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
