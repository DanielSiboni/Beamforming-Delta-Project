options:
  parameters:
    generate_options: qt_gui
    id: mvdr_test_physical
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: c_light_speed
  id: variable
  parameters:
    value: '299792458'
  states: {}
- name: call_seconds
  id: variable
  parameters:
    value: '3.0'
  states: {}
- name: d_x
  id: variable
  parameters:
    value: '0.027'
  states: {}
- name: freq_wave
  id: variable
  parameters:
    value: 5.8e9
  states: {}
- name: freq_wave2
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: lambda_wave
  id: variable
  parameters:
    value: c_light_speed/freq_wave
  states: {}
- name: r_gain
  id: variable_qtgui_range
  parameters:
    label: Reciver Gain
    start: '0'
    step: '1'
    stop: '50'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: t_gain
  id: variable_qtgui_range
  parameters:
    label: Transmitter Gain
    start: '0'
    step: '1'
    stop: '80'
    value: '80'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_wave2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: beamod_mvdr_beamformer_0
  id: beamod_mvdr_beamformer
  parameters:
    ant_positions: '[0, d_x]'
    freq: freq_wave
    snapshots: '51200'
    target_angle: '0'
  states: {}
- name: beamod_two_channel_aligner_0
  id: beamod_two_channel_aligner
  parameters:
    cal_duration_sec: call_seconds
    sample_rate: samp_rate
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Freq Transmit"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Freqs Waves After Fix"'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Freqs Waves Before Fix"'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Freqs Waves After MVDR"'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Second_wave"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq_wave
    dev_addr: '"serial=3557005"'
    gain0: t_gain
    samp_rate: samp_rate
    sd_spec0: '"A:A"'
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: freq_wave
    center_freq1: freq_wave
    dev_addr: '"serial=356E617"'
    gain0: r_gain
    gain1: r_gain
    nchan: '2'
    samp_rate: samp_rate
    sd_spec0: '"A:A A:B"'
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [beamod_mvdr_beamformer_0, '0', qtgui_freq_sink_x_0_0_1, '1']
- [beamod_mvdr_beamformer_0, '0', qtgui_time_sink_x_1, '0']
- [beamod_two_channel_aligner_0, '0', beamod_mvdr_beamformer_0, '0']
- [beamod_two_channel_aligner_0, '0', qtgui_freq_sink_x_0_0, '0']
- [beamod_two_channel_aligner_0, '0', qtgui_freq_sink_x_0_0_1, '0']
- [beamod_two_channel_aligner_0, '1', beamod_mvdr_beamformer_0, '1']
- [beamod_two_channel_aligner_0, '1', qtgui_freq_sink_x_0_0, '1']
- [uhd_usrp_source_0_0, '0', beamod_two_channel_aligner_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [uhd_usrp_source_0_0, '1', beamod_two_channel_aligner_0, '1']
- [uhd_usrp_source_0_0, '1', qtgui_freq_sink_x_0_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
