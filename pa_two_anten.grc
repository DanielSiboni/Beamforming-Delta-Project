options:
  parameters:
    generate_options: qt_gui
    id: pa_two_anten
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: c_light_speed
  id: variable
  parameters:
    value: '299792458'
  states: {}
- name: d_x
  id: variable
  parameters:
    value: lambda_wave / 2
  states: {}
- name: freq_wave
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: lambda_wave
  id: variable
  parameters:
    value: c_light_speed/freq_wave
  states: {}
- name: phase_diff
  id: variable
  parameters:
    value: '2*np.pi* d_x * np.sin(recv_theta) / lambda_wave '
  states: {}
- name: r_gain
  id: variable_qtgui_range
  parameters:
    label: Reciver Gain
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: recv_theta
  id: variable_qtgui_range
  parameters:
    label: R Angle
    start: '-np.pi / 2'
    step: '0.01'
    stop: np.pi / 2
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_phase_shift_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'True'
    shift: 0*phase_diff
  states: {}
- name: blocks_phase_shift_0_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'True'
    shift: 1*phase_diff
  states: {}
- name: blocks_phase_shift_0_1
  id: blocks_phase_shift
  parameters:
    is_radians: 'True'
    shift: 3*phase_diff
  states: {state: disabled}
- name: blocks_phase_shift_0_2
  id: blocks_phase_shift
  parameters:
    is_radians: 'True'
    shift: 4*phase_diff
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq_wave
    fftsize: '1024'
    name: '"Freqs"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq_wave
    fftsize: '1024'
    name: '"Freqs First Channel"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Total waves"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"First Wave"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Second_wave"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: freq_wave
    center_freq1: freq_wave
    gain0: r_gain
    gain1: r_gain
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_phase_shift_0, '0', blocks_add_xx_0, '0']
- [blocks_phase_shift_0_0, '0', blocks_add_xx_0, '1']
- [uhd_usrp_source_0_0, '0', blocks_phase_shift_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [uhd_usrp_source_0_0, '1', blocks_phase_shift_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
